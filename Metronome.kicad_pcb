# Repository wkevina/micronome-pcb

## KiCad design Metronome.kicad_pcb

Parts:
7Seg1: 7segment_3digit; LDT-N2804RI
C1, C2, C5: 0.01u; C_0402
C3, C6: 0.1u; C_0402
C4, C7: 10u; C_0402
C8, C9: 4.7u; C_0402
CON1: PDI_50mil; header_2x5_th
IC1: ATXMEGA8E5-MU; QFN-32-1EP_5x5mm_Pitch0.5mm
P1: USB_B; USB_Micro-B_smd
Q1: Q_PMOS_GSD; SOT-23
R1, R2, R3, R4, R5, R6, R7: 10k; R_0402
R8, R9: 21k; R_0402
R10, R11, R12: 41.2k; R_0402
S1: ENCODER_SW; EC09E15244xx
SP1: SPEAKER; kobitone_9.6mm_buzzer
U1: AS1117; QFN-24-1EP_4x4mm_Pitch0.5mm
U2: NCP706A; XDFN8_1.6x1.2
Y1: Crystal; crystal_ABS05_Abracon_smd

Connections:
/ROTA: C2.1, IC1.28 (PD0/ADC8/SDA/IN1/OUT0/AREF), R4.2
/ROTB: C5.1, IC1.27 (PD1/ADC1/XCK0/SCL/IN2), R7.1
/SW1: C1.1, IC1.26 (PD2/ADC10/RXD0/IN0/OC0), R2.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, CON1.2 (GND), IC1.1 (GND), IC1.18 (GND), IC1.33, P1.4, P1.5, P1.6, S1.1 (G), S1.4, SP1.2, U1.3 (GND), U1.25, U2.5 (GND), U2.9
unnamed: 7Seg1.1 (e), U1.18 (SEGE)
unnamed: 7Seg1.2 (d), U1.20 (SEGD)
unnamed: 7Seg1.4 (c), U1.17 (SEGC)
unnamed: 7Seg1.5 (g), U1.15 (SEGG)
unnamed: 7Seg1.7 (b), U1.14 (SEGB)
unnamed: 7Seg1.8 (CC3), U1.6 (DIG6)
unnamed: 7Seg1.9 (CC2), U1.5 (DIG5)
unnamed: 7Seg1.10 (f), U1.13 (SEGF)
unnamed: 7Seg1.11 (a), U1.12 (SEGA)
unnamed: 7Seg1.12 (CC1), U1.24 (DIG1)
unnamed: C9.1, P1.1, U2.6 (EN), U2.7 (Vin), U2.8 (Vin)
unnamed: CON1.3 (PDI_Data), IC1.7 (PDI_DATA)
unnamed: CON1.6 (PDI_Clk), IC1.8 (~RESET~/PDI_CLK), R1.2
unnamed: IC1.15 (IN2/SCL/XCK0/OC4AHS/OC4B/PC1), R8.2, U1.11 (SCL)
unnamed: IC1.16 (OUT0/IN1/SDA/~OC4ALS~/OC4A/PC0), R9.2, U1.22 (SDA)
unnamed: IC1.19 (PR1/XTAL1/TOSC1/EXTCLK/AC0OUT), Y1.2
unnamed: IC1.20 (PR0/XTAL2/TOSC2/CLKOUT/EVOUT/RTCOUT/AC1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), Y1.1
unnamed: IC1.31 (AC5/ADC5/PA5), Q1.1 (G)
unnamed: Q1.2 (S), SP1.1
unnamed: R2.1, R3.2, S1.5
unnamed: R4.1, R5.2, S1.2 (A)
unnamed: R6.2, R7.2, S1.3 (B)
unnamed: R10.1, U1.21 (IRQ)
unnamed: R11.1, U1.9 (RST)
unnamed: R12.1, U1.10 (Iset)
VCC: C3.1, C4.1, C6.2, C7.2, C8.1, CON1.4 (VTG), IC1.17 (VCC), IC1.32 (AVCC), Q1.3 (D), R1.1, R3.1, R5.1, R6.1, R8.1, R9.1, R10.2, R11.2, R12.2, U1.16 (VDD), U2.1 (VOUT), U2.2 (VOUT), U2.4 (SNS)

Board: 2 copper layers, 24.8 x 24.5 mm, 31 parts (24 on the bottom side), 30 nets.

## KiCad design backup.kicad_pcb

Board: 2 copper layers, 25.5 x 25.5 mm, 27 parts (1 on the bottom side), 26 nets.

Parts:
AFF1, AFF2, AFF3: 7SEGMENTS; 7SEG_3.3x5.08
C1, C2, C5: 0.01u; C_0603_HandSoldering
C3, C6: 0.1u; C_0603_HandSoldering
C4, C7: 10u; C_0603_HandSoldering
C8: 1u; C_0603_HandSoldering
IC1: ATXMEGA8E5-MU; QFN-32-1EP_5x5mm_Pitch0.5mm
R1, R2, R3, R4, R5, R6, R7: 10k; R_0603_HandSoldering
R8, R9: 20k; R_0603_HandSoldering
R10, R11, R12: 40k; R_0603_HandSoldering
S1: ENCODER_SW; EC09E15244xx
U1: AS1117; QFN-24-1EP_4x4mm_Pitch0.5mm
U2: NCP706A; XDFN8_1.6x1.2

Connections:
/ROTA: C2.1, IC1.28, R4.2
/ROTB: C5.1, IC1.27, R7.1
/SW1: C1.1, IC1.26, R2.2
/a1: AFF1.7, AFF2.7, AFF3.7, U1.12
/a2: AFF1.6, AFF2.6, AFF3.6, U1.14
/a3: AFF1.4, AFF2.4, AFF3.4, U1.17
/a4: AFF1.2, AFF2.2, AFF3.2, U1.20
/a5: AFF1.1, AFF2.1, AFF3.1, U1.18
/a6: AFF1.9, AFF2.9, AFF3.9, U1.13
/a7: AFF1.10, AFF2.10, AFF3.10, U1.15
/a8: AFF1.5, AFF2.5, AFF3.5, U1.19
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, IC1.1, IC1.18, S1.1, S1.4, U1.3, U2.5
unnamed: AFF1.3, AFF1.8, U1.23
unnamed: AFF2.3, AFF2.8, U1.24
unnamed: AFF3.3, AFF3.8, U1.1
unnamed: IC1.8, R1.2
unnamed: IC1.15, R8.2, U1.11
unnamed: IC1.16, R9.2, U1.22
unnamed: R2.1, R3.1, S1.5
unnamed: R4.1, R5.1, S1.2
unnamed: R6.2, R7.2, S1.3
unnamed: R10.1, U1.21
unnamed: R11.1, U1.9
unnamed: R12.1, U1.10
unnamed: U2.6, U2.7, U2.8
VCC: C3.1, C4.1, C6.2, C7.2, C8.1, IC1.17, IC1.32, R1.1, R3.2, R5.2, R6.1, R8.1, R9.1, R10.2, R11.2, R12.2, U1.16, U2.1, U2.2, U2.4

## Commit log

2015-10-28 Initial commit. A little late, but we'll call it rev 1.
2015-10-29 Add python bom export scripts
2015-10-29 Hide footprints and MFP fields in schematic.
2015-10-29 Remove unused component libraries.
2015-10-29 Remove cache library.
2015-10-29 Set proper pin direction to fix ERC errors.
2015-10-29 Optimize layout to fit buzzer on board. Add ID pin to USB micro B connector.
2015-10-30 Not sure.
2015-10-30 Convert NPTH to PTH
2015-10-30 Add 32kHz crystal to XMega circuit.
2016-05-11 No change
2016-05-11 Add license and readme
2016-05-11 Update copyright on board
2016-05-11 Plot references in gerbers

Notices in the files:
Metronome.kicad_pcb:
© Kevin Ward 2016
